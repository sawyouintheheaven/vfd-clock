# Keil uVision project vfd-6311.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: vfd-6311 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: pt6311.c main.c ds3231.c myiicForDs3231.c dht11.c eeprom.c
